# Keil uVision project v1.1.uvprojx, settings and files
target v1.1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: v1_1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/digital;../BSP/ioLibrary_Driver/Ethernet;../BSP/ioLibrary_Driver/Ethernet/W5500;../BSP/ioLibrary_Driver/Internet/DHCP;../BSP/ioLibrary_Driver;../BSP/ioLibrary_Driver/Application/loopback;../BSP/lfs;../BSP/HAL_FLASH;../BSP/msh;../BSP/extern_flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group flash
    ../BSP/HAL_FLASH/: hal_flash.c hal_flash.h
    ../BSP/extern_flash/: driver_w25qxx.c app_w25qxx.c app_w25qxx.h driver_w25qxx.h
  group Ethernet
    ../BSP/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../BSP/ioLibrary_Driver/Ethernet/W5500/: w5500.c
    ../BSP/ioLibrary_Driver/Internet/DHCP/: dhcp.c
    ../BSP/ioLibrary_Driver/: wiz_platform.c wiz_platform.h app_w5500.c app_w5500.h
    ../BSP/ioLibrary_Driver/Application/loopback/: loopback.c loopback.h
  group lfs
    ../BSP/lfs/: lfs.c lfs_user.c lfs_user_example.c lfs_util.c
  group msh
    ../BSP/msh/: msh.c msh.h
  group digital
    ../BSP/digital/: digital.c digital.h
software components: CMSIS:CORE 4.3.0
