# Keil uVision project v2.0.uvprojx, settings and files
target v2.0 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: v2_0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/digital;../BSP/extern_flash;../BSP/HAL_FLASH;../BSP/ioLibrary_Driver/Application/loopback;../BSP/ioLibrary_Driver/Ethernet;../BSP/ioLibrary_Driver/Ethernet/W5500;../BSP/ioLibrary_Driver/Internet/DHCP;../BSP/ioLibrary_Driver;../BSP/lfs;../BSP/msh;..\BSP\env;..\BSP\cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group flash
    ../BSP/extern_flash/: app_w25qxx.c app_w25qxx.h driver_w25qxx.c driver_w25qxx.h
    ../BSP/HAL_FLASH/: hal_flash.c hal_flash.h
  group Ethernet
    ../BSP/ioLibrary_Driver/: app_w5500.c app_w5500.h wiz_platform.c wiz_platform.h
    ../BSP/ioLibrary_Driver/Application/loopback/: loopback.c loopback.h
    ../BSP/ioLibrary_Driver/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
    ../BSP/ioLibrary_Driver/Ethernet/W5500/: w5500.c w5500.h
    ../BSP/ioLibrary_Driver/Internet/DHCP/: dhcp.c dhcp.h
  group lfs
    ../BSP/lfs/: lfs.c lfs.h lfs_user.c lfs_user.h lfs_util.c lfs_util.h
  group msh
    ../BSP/msh/: msh.c msh.h
  group digital
    ../BSP/digital/: digital.c digital.h
  group env
    ../BSP/env/: temp.c temp.h
  group cJSON
    ../BSP/cJSON/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h cJSON_fieldManage.h
software components: CMSIS:CORE 4.3.0
